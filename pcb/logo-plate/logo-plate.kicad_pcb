File: pcb/logo-plate/logo-plate.kicad_pcb (KiCad board)
At the start: 2 copper layers, 169 x 18 mm, 1 part

Commit message: sync
Routing:
- added copper zone on F.Cu, net (none)
